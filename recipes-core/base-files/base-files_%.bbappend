FILESEXTRAPATHS:prepend := "${THISDIR}/base-files:"

SRC_URI:append = " file://fstab"

